# Keil uVision project STM32F103.uvprojx, settings and files
target Temple (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, STM32F103xE
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\Users;..\..\Drivers\SYSTEM\sys;..\..\Drivers\SYSTEM\delay;..\..\Drivers\SYSTEM\usart1;..\..\Drivers\BSP\beep;..\..\Drivers\BSP\keyboard;..\..\Drivers\BSP\oled;..\..\Drivers\BSP\password;..\..\Drivers\BSP\relay_lock;..\..\Drivers\BSP\w25q128;..\..\Drivers\BSP\oled_ui;..\..\Drivers\BSP\timer;..\..\Drivers\BSP\tasks;..\..\Drivers\BSP\adc;..\..\Drivers\BSP\relay_fan;..\..\Drivers\BSP\bluetooth;..\..\Drivers\BSP\led;..\..\Drivers\BSP\voice;..\..\Drivers\BSP\dht11;..\..\Drivers\BSP\esp8266;..\..\Drivers\BSP\onenet
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f100xe.s
  group User
    ../../Users/: main.c stm32f1xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/usart1/: usart1.c
  group Drivers/STM32Fxx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group Drivers/BSP
    ../../Drivers/BSP/beep/: beep.c
    ../../Drivers/BSP/keyboard/: keyboard.c
    ../../Drivers/BSP/oled/: oled.c
    ../../Drivers/BSP/password/: password.c
    ../../Drivers/BSP/relay_lock/: relay_lock.c
    ../../Drivers/BSP/w25q128/: w25q128.c
    ../../Drivers/BSP/oled_ui/: oled_ui.c
    ../../Drivers/BSP/tasks/: tasks.c
    ../../Drivers/BSP/timer/: timer.c
    ../../Drivers/BSP/adc/: adc.c
    ../../Drivers/BSP/relay_fan/: relay_fan.c
    ../../Drivers/BSP/bluetooth/: bluetooth.c
    ../../Drivers/BSP/led/: led.c
    ../../Drivers/BSP/voice/: voice.c
    ../../Drivers/BSP/esp8266/: esp8266.c
    ../../Drivers/BSP/dht11/: dht11.c
    ../../Drivers/BSP/onenet/: onenet.c
